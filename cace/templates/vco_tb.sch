** sch_path: cace/templates/vco_tb.sch
**.subckt vco_tb
V0 VSS GND 0
V6 VDD GND 1.8
I0 net1 Vc CACE{icont}
x1 VDD VSS Vc Vn0 Vn1 Vn2 Vn3 Vp0 Vp1 Vp2 Vp3 Vb vco
Vmeas VDD net1 0
.save i(vmeas)
**** begin user architecture code


.control
	save all
	tran 10n 40000n

	let period=2e6
	meas tran period TRIG vp0 VAL=0.9 RISE=5 TARG vp0 VAL=0.9 RISE=6
	meas tran vb_avg AVG vb from=1n to=9n
	meas tran vc_avg AVG vc from=1n to=9n
	meas tran icont_avg AVG i(vmeas) from=1n to=9n

	let frequency = 1 / period
	echo $&icont_avg $&frequency $&vc_avg $&vb_avg > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

*.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1

.option klu

.option num_threads=2


**** end user architecture code
**.ends

* expanding   symbol:  vco.sym # of pins=12
** sym_path: xschem-pex/vco.sym
.include ./vco.spice
.GLOBAL GND
.end
