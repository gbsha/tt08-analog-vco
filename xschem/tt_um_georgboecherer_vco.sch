v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 340 -40 1 0 {name=p6 lab=clk}
C {devices/ipin.sym} 370 -40 1 0 {name=p7 lab=ena}
C {devices/ipin.sym} 310 -40 1 0 {name=p3 lab=rst_n}
C {devices/ipin.sym} 210 340 0 0 {name=p14 lab=ua[0]}
C {devices/ipin.sym} 510 340 2 0 {name=p13 lab=ua[1]}
C {devices/ipin.sym} -110 40 3 0 {name=p12 lab=ua[2]}
C {devices/ipin.sym} -140 40 3 0 {name=p11 lab=ua[3]}
C {devices/ipin.sym} -170 40 3 0 {name=p10 lab=ua[4]}
C {devices/ipin.sym} -200 40 3 0 {name=p9 lab=ua[5]}
C {devices/ipin.sym} -230 40 3 0 {name=p8 lab=ua[6]}
C {devices/ipin.sym} -260 40 3 0 {name=p2 lab=ua[7]}
C {devices/ipin.sym} 250 -40 1 0 {name=p22 lab=ui_in[0]}
C {devices/ipin.sym} 220 -40 1 0 {name=p21 lab=ui_in[1]}
C {devices/ipin.sym} 190 -40 1 0 {name=p20 lab=ui_in[2]}
C {devices/ipin.sym} 160 -40 1 0 {name=p19 lab=ui_in[3]}
C {devices/ipin.sym} 130 -40 1 0 {name=p18 lab=ui_in[4]}
C {devices/ipin.sym} 100 -40 1 0 {name=p17 lab=ui_in[5]}
C {devices/ipin.sym} 70 -40 1 0 {name=p16 lab=ui_in[6]}
C {devices/ipin.sym} 40 -40 1 0 {name=p15 lab=ui_in[7]}
C {devices/ipin.sym} -50 -40 1 0 {name=p29 lab=uio_in[0]}
C {devices/ipin.sym} -80 -40 1 0 {name=p28 lab=uio_in[1]}
C {devices/ipin.sym} -110 -40 1 0 {name=p27 lab=uio_in[2]}
C {devices/ipin.sym} -140 -40 1 0 {name=p26 lab=uio_in[3]}
C {devices/ipin.sym} -170 -40 1 0 {name=p25 lab=uio_in[4]}
C {devices/ipin.sym} -200 -40 1 0 {name=p24 lab=uio_in[5]}
C {devices/ipin.sym} -230 -40 1 0 {name=p23 lab=uio_in[6]}
C {devices/ipin.sym} -260 -40 1 0 {name=p1 lab=uio_in[7]}
C {devices/ipin.sym} 330 400 3 0 {name=p30 lab=uo_out[0]}
C {devices/ipin.sym} 450 400 3 0 {name=p31 lab=uo_out[1]}
C {devices/ipin.sym} 430 400 3 0 {name=p32 lab=uo_out[2]}
C {devices/ipin.sym} 310 400 3 0 {name=p33 lab=uo_out[3]}
C {devices/ipin.sym} 290 400 3 0 {name=p34 lab=uo_out[4]}
C {devices/ipin.sym} 410 400 3 0 {name=p35 lab=uo_out[5]}
C {devices/ipin.sym} 390 400 3 0 {name=p36 lab=uo_out[6]}
C {devices/ipin.sym} 270 400 3 0 {name=p37 lab=uo_out[7]}
C {devices/iopin.sym} 360 280 3 0 {name=p4 lab=VDPWR}
C {devices/iopin.sym} 360 400 1 0 {name=p5 lab=VGND}
C {vco.sym} 360 340 0 0 {name=x1}
